Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: HK-800DA.IFC
Time: 2022-01-04T06:06:18
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: TUBE
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 德芮達_800DA外殼_逆向工程 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 背板
In: Default Storey
PredefinedType: ELEMENT; Material: Steel
